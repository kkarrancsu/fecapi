<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>35000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framebits</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>esno_0</value></param>
<param><key>value</key><value>numpy.arange(0, 4, .25) </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import fec</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_decoder_def</key>
<param><key>id</key><value>variable_cc_def_fecapi_decoder_def_0</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>dim1</key><value>len(esno_0)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_encoder_def</key>
<param><key>id</key><value>variable_cc_def_fecapi_encoder_def_0</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>dim1</key><value>len(esno_0)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>wxgui_curvesink</key>
<param><key>id</key><value>wxgui_curvesink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>title</key><value>Curve Plot</value></param>
<param><key>x_units</key><value></value></param>
<param><key>y_units</key><value></value></param>
<param><key>x_vals</key><value>esno_0</value></param>
<param><key>y_per_div</key><value>1</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>legends</key><value>map(str, range(1))</value></param>
<param><key>fft_rate</key><value>100</value></param>
</block>
<block>
<key>bercurve</key>
<param><key>id</key><value>bercurve_0_0</value></param>
<param><key>esno</key><value>esno_0</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
<param><key>encoder_list</key><value>variable_cc_def_fecapi_encoder_def_0</value></param>
<param><key>decoder_list</key><value>variable_cc_def_fecapi_decoder_def_0</value></param>
<param><key>threadtype</key><value>capillary</value></param>
<param><key>berminerrors</key><value>200</value></param>
<param><key>berlimit</key><value>-7</value></param>
<param><key>puncpat</key><value>'1101'</value></param>
</block>
<connection><source_block_id>bercurve_0_0</source_block_id><sink_block_id>wxgui_curvesink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
