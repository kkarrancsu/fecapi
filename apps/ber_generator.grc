<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ber_generator</value></param>
<param><key>title</key><value>BER Generator</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>FEC</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>generic_encoder</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>generic_decoder</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>esno</value></param>
<param><key>label</key><value>EsNo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>berminerrors</value></param>
<param><key>value</key><value>100</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>berlimit</value></param>
<param><key>value</key><value>-5.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threading</value></param>
<param><key>value</key><value>capillary</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>ber_bb</key>
<param><key>id</key><value>ber_bb_0_0</value></param>
<param><key>berminerrors</key><value>berminerrors</value></param>
<param><key>berlimit</key><value>berlimit</value></param>
</block>
<block>
<key>gr_unpacked_to_packed_xx</key>
<param><key>id</key><value>gr_unpacked_to_packed_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>gr_unpacked_to_packed_xx</key>
<param><key>id</key><value>gr_unpacked_to_packed_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>num_ports</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from fec.bitflip import read_bitlist</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import fec</value></param>
</block>
<block>
<key>generic_encoder</key>
<param><key>id</key><value>generic_encoder_0</value></param>
<param><key>encoder</key><value>generic_encoder</value></param>
<param><key>itype</key><value>byte</value></param>
<param><key>otype</key><value>float</value></param>
</block>
<block>
<key>gaussnoise_ff</key>
<param><key>id</key><value>gaussnoise_ff_0</value></param>
<param><key>esno</key><value>esno</value></param>
</block>
<block>
<key>puncture_ff</key>
<param><key>id</key><value>puncture_ff_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>puncpat</key><value>read_bitlist(puncpat)</value></param>
<param><key>puncholes</key><value>puncpat.count('0')</value></param>
<param><key>puncsize</key><value>len(puncpat)</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>14000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>random_gen_b</key>
<param><key>id</key><value>random_gen_b_0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>value</key><value>'11'</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>decoder_interface</key>
<param><key>id</key><value>decoder_interface_0</value></param>
<param><key>decoder_list</key><value>generic_decoder</value></param>
<param><key>threadtype</key><value>capillary</value></param>
<param><key>ann</key><value>None</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>pre</key><value>None</value></param>
<param><key>fops</key><value>None</value></param>
<param><key>flush</key><value>10000</value></param>
</block>
<connection><source_block_id>gr_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>ber_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_unpacked_to_packed_xx_0</source_block_id><sink_block_id>ber_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>generic_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>gr_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ber_bb_0_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>decoder_interface_0</source_block_id><sink_block_id>gr_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_gen_b_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>generic_encoder_0</source_block_id><sink_block_id>puncture_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>puncture_ff_0</source_block_id><sink_block_id>gaussnoise_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gaussnoise_ff_0</source_block_id><sink_block_id>decoder_interface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_gen_b_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
