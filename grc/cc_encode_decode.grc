<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_decoder_def</key>
<param><key>id</key><value>variable_cc_def_fecapi_decoder_def_0</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>dim2</key><value>4</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>k</key><value>7</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>variable_decoder_interface</key>
<param><key>id</key><value>variable_decoder_interface_0</value></param>
<param><key>value</key><value>statdard_decoder_interface</value></param>
<param><key>decoder_list</key><value>variable_cc_def_fecapi_decoder_def_0</value></param>
<param><key>threadtype</key><value>capillary</value></param>
<param><key>ann</key><value>None</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>encoder_interface</key>
<param><key>id</key><value>encoder_interface_0</value></param>
<param><key>encoder_list</key><value>variable_cc_def_fecapi_encoder_def_0</value></param>
<param><key>threadtype</key><value>capillary</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_encoder_def</key>
<param><key>id</key><value>variable_cc_def_fecapi_encoder_def_0</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>dim2</key><value>4</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>k</key><value>7</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>4096</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>encoder_interface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>encoder_interface_0</source_block_id><sink_block_id>variable_decoder_interface_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>variable_decoder_interface_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
